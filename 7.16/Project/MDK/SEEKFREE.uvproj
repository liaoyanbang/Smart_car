# Keil uVision project SEEKFREE.uvproj, settings and files
target STC16F40K (MCS-251)
  device: STC16F40K128 Series STC
  cpu: IRAM(0-0x1FFF) XRAM(0x10000-0x17FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: SEEKFREE +hex
  link misc: REMOVEUNUSED
  group startup
    ../../Libraries/libraries/: board.h board.c common.c common.h SEEKFREE_PRINTF.c SEEKFREE_PRINTF.h STC16Fxx.h STC_DFP.LIB STC16_MDU32_V1.0.LIB
    ../../../../: STC16_FPMU_V1.0.LIB
  group seekfree_libraries
    ../../Libraries/seekfree_peripheral/: headfile.h
    ../../Libraries/seekfree_libraries/: zf_adc.c zf_adc.h zf_delay.c zf_delay.h zf_exti.c zf_exti.h zf_gpio.c zf_gpio.h zf_iic.c zf_iic.h zf_nvic.c zf_nvic.h zf_pwm.c zf_pwm.h zf_spi.c zf_spi.h zf_tim.c zf_tim.h zf_uart.c zf_uart.h
  group seekfree_peripheral
    ../../Libraries/seekfree_peripheral/: SEEKFREE_18TFT.c SEEKFREE_18TFT.h SEEKFREE_ABSOLUTE_ENCODER.c SEEKFREE_ABSOLUTE_ENCODER.h SEEKFREE_FONT.c SEEKFREE_FONT.h SEEKFREE_ICM20602.c SEEKFREE_ICM20602.h SEEKFREE_IIC.c SEEKFREE_IIC.h SEEKFREE_IPS114_SPI.c SEEKFREE_IPS114_SPI.h SEEKFREE_MPU6050.c SEEKFREE_MPU6050.h SEEKFREE_OLED.c SEEKFREE_OLED.h SEEKFREE_TSL1401.c SEEKFREE_TSL1401.h SEEKFREE_VIRSCO.c SEEKFREE_VIRSCO.h SEEKFREE_WIRELESS.h SEEKFREE_WIRELESS.c SEEKFREE_AT24C02.c SEEKFREE_AT24C02.h SEEKFREE_BLUETOOTH_CH9141.c SEEKFREE_BLUETOOTH_CH9141.h
    ../../Libraries/seekfree_libraries/: zf_fifo.c zf_fifo.h
  group doc
    ../../Libraries/doc/: version.txt
  group user_c
    ../USER/src/: isr.c main.c Fuzzy_pid.c pid.c ANO_DT.c
  group user_h
    ../USER/inc/: isr.h pid.h Fuzzy_pid.h ANO_DT.h
